<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\define.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\ISR.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\ISR.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\ISR_FUN.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MKL_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\MKL_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MKL_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\mymath.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\PORT_cfg.h</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\dial_switch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\filter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\getspeed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\image2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\image_process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\imu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\mpu6050.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\mpuiic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\mykey.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\myPWM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\OV7725.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\Src\SCCB.c</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_TPM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\startup_MKL.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\system_MKL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\vectors.c</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\iar_cortexM0plusl_math.a</name>
      </file>
    </group>
  </group>
</project>


